# IAR project SweepRobot_Testing_Host.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; __FPU_PRESENT=1; __FPU_USED=1; ARM_MATH_CM4; __CC_ARM; _USE_ACTUAL_POS_DETECT_KEY
  ICCARM.CCIncludePath2: ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\Devices\ST\IAR; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Lib\ARM; ..\..\User\BSP\inc; ..\..\Middlewares\UCOSII\CONFIG; ..\..\Middlewares\UCOSII\CORE; ..\..\Middlewares\UCOSII\PORT; ..\..\User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group App
    ../../User/APP/src/: sweeprobot_testing_ash_tray.c sweeprobot_testing_brush.c sweeprobot_testing_buzzer.c sweeprobot_testing_charge.c sweeprobot_testing_collision.c sweeprobot_testing_fan.c sweeprobot_testing_front_ifrd.c sweeprobot_testing_ifrd.c sweeprobot_testing_irda.c sweeprobot_testing_key.c sweeprobot_testing_manul.c sweeprobot_testing_rgb_led.c sweeprobot_testing_uniwheel.c sweeprobot_testing_wheel.c sweeprobot_testing_wheel_float.c
  group IAR_ARM/core
    ../../Libraries/CMSIS/Devices/ST/IAR/: startup_stm32f40_41xxx.s
  group Middleware/uCOS/config
    ../../Middlewares/UCOSII/CONFIG/: includes.h os_cfg.h
  group Middleware/uCOS/core
    ../../Middlewares/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Middleware/uCOS/port
    ../../Middlewares/UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group User
    ../../User/APP/src/: sweeprobot_testing.c
