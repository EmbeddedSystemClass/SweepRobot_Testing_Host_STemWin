# Keil uVision project SweepRobot_Testing_Host.uvprojx, settings and files
target SweepRobot_Testing_Host_STemWin_uCOSII (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SweepRobotTestHost +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: _USE_ACTUAL_POS_DETECT_KEY, _SHOW_SLAM_DLG,STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c misc: --C99
  c include: ..\..\User\BSP\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Lib\ARM;..\..\Middlewares\STemWinLibrary528\inc;..\..\Middlewares\STemWinLibrary528\Config;..\..\Middlewares\STemWinLibrary528\EMWIN_DEMO\inc;..\..\Middlewares\FATFS\inc;..\..\Middlewares\FONTS\inc;..\..\Middlewares\UCOSII\CONFIG;..\..\Middlewares\UCOSII\CORE;..\..\Middlewares\UCOSII\PORT;..\..\Libraries\CMSIS\Devices\ST;..\..\Libraries\STM32F4xx_Ext\inc;..\..\User;..\..\User\Framework\GUI\inc;..\..\User\APP\inc;..\..\User\Framework\GUI\res\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Bsp
    ../../User/BSP/src/: 24cxx.c crypto_tea.c ctiic.c delay.c ft5206.c gt9147.c ILI93xx.c key.c led.c malloc.c myiic.c ott2001a.c remote.c rtc.c sdio_sdcard.c spi.c sram.c sys.c timer.c touch.c usart.c w25qxx.c
  group Bsp\swrbtest
    ../../User/BSP/src/: swrbTestDriver.c swrbTestSteerMotorDriver.c swrbTestStepMotorDriver_WithAcc.c
  group Doc
    ./: Prototype of GUI.txt
  group Freamwork\gui
    ../../User/Framework/GUI/inc/: EJE_SWRB_TEST_DLG_Conf.h
    ../../User/Framework/GUI/src/: EJE_SWRB_TEST_DLG_Conf.c EJE_SWRB_TEST_StartDLG.c EJE_SWRB_TEST_PCBTestDLG.c EJE_SWRB_TEST_ManulDLG.c EJE_SWRB_TEST_SNSettingDLG.c EJE_SWRB_TEST_TimeSettingDLG.c EJE_SWRB_TEST_TestSelSettingDLG.c EJE_SWRB_TEST_LoginDLG.c EJE_SWRB_TEST_NumPadDLG.c EJE_SWRB_TEST_RelayCtrlDLG.c EJE_SWRB_TEST_StepMotorTestDLG.c EJE_SWRB_TEST_SteerMotorTestDLG.c EJE_SWRB_TEST_SLAMDLG.c EJE_SWRB_TEST_DecryptoDLG.c
  group Freamwork\res
    ../../User/Framework/GUI/res/src/: eje_logo_char.c DibeaLogo_300x64.c eje_CHNFont_Songti32.c eje_CHNFont_Yahei30.c eje_CHNFont_Songti24.c eje_CHNFont_Songti18.c
  group Libararies\dsp_lib
    ../../Libraries/CMSIS/Include/: arm_math.h
    ../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Libaraies\stdperiph
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group MDK_ARM\core
    ../../Libraries/CMSIS/Include/: core_cm4.h core_cm4_simd.h
    ../../Libraries/CMSIS/Devices/ST/MDK/: startup_stm32f40_41xxx.s
  group Middlewares\fatfs
    ../../Middlewares/FATFS/src/: diskio.c ff.c
    ../../Middlewares/FATFS/src/option/: syscall.c
    ../../Middlewares/FATFS/exfans/: exfans.c fattester.c mycc936.c
  group Middlewares\font_lib
    ../../Middlewares/FONTS/src/: fontupd.c mytext.c SDErrCHN.c
  group Middlewares\stemwin
    ../../Middlewares/STemWinLibrary528/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c LCDConf.h GUIConf.h
    ../../Middlewares/STemWinLibrary528/OS/: GUI_X_UCOSII.c
    ../../Middlewares/STemWinLibrary528/Lib/: STemWin528_CM4_OS_Keil.lib
  group Middlewares\ucosii_core
    ../../Middlewares/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Middlewares\ucosii_port
    ../../Middlewares/UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group Middlewares\ucosii_config
    ../../Middlewares/UCOSII/CONFIG/: includes.h os_cfg.h
  group User\app\slam
    ../../User/APP/src/: sweeprobot_slam_monitor.c
  group User\app\test
    ../../User/APP/src/: sweeprobot_testing.c sweeprobot_testing_manul.c sweeprobot_testing_wheel.c sweeprobot_testing_brush.c sweeprobot_testing_fan.c sweeprobot_testing_ifrd.c sweeprobot_testing_front_ifrd.c sweeprobot_testing_collision.c sweeprobot_testing_wheel_float.c sweeprobot_testing_ash_tray.c sweeprobot_testing_uniwheel.c sweeprobot_testing_key.c sweeprobot_testing_irda.c sweeprobot_testing_buzzer.c sweeprobot_testing_rgb_led.c sweeprobot_testing_charge.c
  group User
    ../../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
target SweepRobot_Testing_Host_STemWin_FreeRTOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: as above
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: .\BSP\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Libararies\STM32F4xx_StdPeriph_Driver\inc;..\Libararies\CMSIS\Include;..\Libararies\CMSIS\Lib\ARM;..\Middlewares\STemWinLibrary522\inc;..\Middlewares\STemWinLibrary522\Config;..\Middlewares\STemWinLibrary522\EMWIN_DEMO\inc;..\Middlewares\FATFS\exfuns;..\Middlewares\FATFS\src;..\Middlewares\FONTS\inc;..\Middlewares\UCOSII\CONFIG;..\Middlewares\UCOSII\CORE;..\Middlewares\UCOSII\PORT;..\Libararies\CMSIS\Devices\ST;..\Libararies\STM32F4xx_Ext\inc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
